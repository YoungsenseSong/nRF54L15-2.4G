## tests/rf_link_future_c/testcase.yaml
```yaml
tests:
  rf_link.future_c:
    platform_allow:
      - qemu_cortex_m3
    tags:
      - rf_link
      - protocol
```
